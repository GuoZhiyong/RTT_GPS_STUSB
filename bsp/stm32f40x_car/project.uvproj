# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin --output=.\build\app.bin .\build\rtthread-stm32f4xx.axf
  c flags: Optim=3 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_USB_OTG_FS
  c include: .;..\..\components\dfs;..\..\components\dfs\filesystems\elmfat;..\..\components\dfs\filesystems\romfs;..\..\components\dfs\include;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;STM32F4xx_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;STM32F4xx_Libraries\CMSIS\Include;STM32F4xx_Libraries\CMSIS\ST\STM32F4xx\Include;STM32F4xx_Libraries\STM32F4xx_StdPeriph_Driver\inc;STM32F4xx_Libraries\STM32_USB_HOST_Library\Class\MSC\inc;STM32F4xx_Libraries\STM32_USB_HOST_Library\Core\inc;STM32F4xx_Libraries\STM32_USB_OTG_Driver\inc;applications;drivers;..\..\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c startup.c
    ./applications/: jt808.c hmi.c msglist.c jt808_sprintf.c jt808_param.c tree_config.c jt808_gps.c
  group Drivers
    drivers/: board.c stm32f4xx_it.c usb_bsp.c usbh_usr.c
    ./drivers/: printer.c spi_sd.c usbh.c gps.c mma8451.c vuart.c m66.c sst25.c
    ../../components/drivers/src/: ringbuffer.c
  group STM32_StdPeriph
    STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    STM32F4xx_Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    STM32F4xx_Libraries/STM32_USB_HOST_Library/Core/src/: usbh_hcs.c usbh_ioreq.c usbh_core.c usbh_stdreq.c
    STM32F4xx_Libraries/STM32_USB_HOST_Library/Class/Msc/src/: usbh_msc_bot.c usbh_msc_core.c
    STM32F4xx_Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ./STM32F4xx_Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_scsi.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group scr
    ./applications/scr/: scr.c scr_1_signal.c scr_2_driver.c scr_3_geoinfo.c scr_4_sms.c scr_4_1_sms_send.c scr_4_2_sms_inbox.c scr_4_3_sms_outbox.c scr_5_phonecall.c scr_6_advance.c scr_7_mileage.c scr_8_record.c scr_9_tired.c scr_a_vehicle.c scr_b_network.c scr_c_multimedia.c scr_idle.c scr_login.c scr_main.c scr_selfcheck.c str7565r.c scr_export_usb.c
